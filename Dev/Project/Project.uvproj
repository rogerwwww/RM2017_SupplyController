# Keil uVision project Project.uvproj, settings and files
target Open207V (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER, TPP_RELEASE
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\_Common;..\MotorEncoder\BALANCE\CONTROL;..\MotorEncoder\HARDWARE\MOTOR;..\MotorEncoder\HARDWARE\ENCODER;..\MotorEncoder\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
    ../../_Common/: config.c usart.c config.h
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Readme
    ../User/: readme.txt
  group MotorEncoder
    ../MotorEncoder/HARDWARE/MOTOR/: motor.c
    ../MotorEncoder/HARDWARE/TIMER/: timer.c
    ../MotorEncoder/HARDWARE/ENCODER/: encoder.c
    ../MotorEncoder/BALANCE/CONTROL/: control.c
